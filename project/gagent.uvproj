# Keil uVision project gagent.uvproj, settings and files
target 3162_standard (ARM-ADS)
  device: STM32F205RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: GAgent_MX3162_StandardV4
  c flags: Optim=1 uC99=1
  c define: mxchipWNet_HA EMW3162 USE_STDPERIPH_DRIVER GAGENT_STANDARD GAGENT_V4PROTOCOL
  c include: ..\drv\STM32F2xx_StdPeriph_Driver\inc;..\Library;..\HAL;..\..\..\iof;..\..\..\units;..\..\mxchip;..\..\..\gagent\include;..\..\mxchip;..\..\..\gagent\cloud\inc;..\..\..\gagent\lan\inc;..\..\..\gagent\local\inc;..\..\..\..\..\linuxx86\gagent2-0\gagent\include;..\..\..\..\..\linuxx86\gagent2-0\gagent\cloud\inc;..\..\..\..\..\linuxx86\gagent2-0\gagent\lan\inc;..\..\..\..\..\linuxx86\gagent2-0\gagent\local\inc;..\..\..\..\..\linuxx86\gagent2-0\gagent\local\inc;..\..\..\..\..\linuxx86\gagent2-0\iof
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group startup
    ./startup/: startup_stm32f2xx.s
  group adapter
    ../hal_serial/: hal_uart.c
  group STM32_HAL_LIB
    ../drv/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_it.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ../HAL/: flash_if.c mxchipWNet_HA.c system_stm32f2xx.c
  group platform
    ../main/: main.c log.c
  group mxchiWNet
    ../Library/: mxchipWNet_3161.lib mxchipWNet_3162.lib
  group net
    ../main/: net.c
target 3161_standard (ARM-ADS)
  device: STM32F205RG STMicroelectronics
  cpu: as above
  output: GAgent_MX3162_StandardV4
  c flags: Optim=1
  c define: as above
  c include: ..\drv\STM32F2xx_StdPeriph_Driver\inc;..\Library;..\HAL;..\..\..\gizwits\cloud;..\..\..\gizwits\lan;..\..\..\gizwits\local;..\..\..\iof;..\..\..\units
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
